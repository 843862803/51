# Keil uVision project 001.uvproj, settings and files
target Target 1 (MCS-51)
  device: IS89C52 ISSI
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(40000000)
  output: 001 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\c_lib;.\h_lib
  group Source Group 1
    ./: 001.c
    ./c_lib/: uart_send.c delay.c led.c
    ./h_lib/: uart_send.h delay.h led.h
