# Keil uVision project 001.uvproj, settings and files
target Target 1 (MCS-51)
  device: IS89C52 ISSI
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(40000000)
  output: 001 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\part011串口\c_lib;..\..\part011串口\h_lib
  group Source Group 1
    ./: 001.c
    ../../part011串口/c_lib/: delay.c
    ../../part011串口/h_lib/: delay.h
