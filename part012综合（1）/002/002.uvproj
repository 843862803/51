# Keil uVision project 002.uvproj, settings and files
target Target 1 (MCS-51)
  device: IS89C52 ISSI
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(40000000)
  output: 002 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\c_lib;.\h_lib
  group Source Group 1
    ./: main.c
    ./c_lib/: esp8266.c lcd1602.c delay.c
