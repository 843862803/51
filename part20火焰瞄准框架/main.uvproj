# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\c_lib;.\h_lib
  group Source Group 1
    ./: main.c
    ./c_lib/: delay.c key.c display.c XPT2046.c
