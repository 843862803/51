# Keil uVision project part2_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: IS89C52 ISSI
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(40000000)
  output: part2_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: part2_1.c
